# IAR project Project.ewp, settings and files
configuration Charging-Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; EMPL_TARGET_STM32L15X; MPU6050
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\Application; ..\Application\eMPL; ..\Application\QP-nano; ..\Application\protocol; ..\Application\Hardware; ..\Application\Hardware\MPU6050; ..\Application\driver; ..\Application\userlib; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\Third_Party\FreeRTOSV7.3.0\portable\IAR\ARM_CM3; ..\..\..\Utilities\Third_Party\FreeRTOSV7.3.0\include; ..\..\..\Utilities\Third_Party\FreeRTOSV7.3.0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Charging-Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\Application; ..\Application\eMPL; ..\Application\protocol; ..\Application\Hardware; ..\Application\Hardware\MPU6050; ..\Application\driver; ..\Application\userlib; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\Third_Party\FreeRTOSV7.3.0\portable\IAR\ARM_CM3; ..\..\..\Utilities\Third_Party\FreeRTOSV7.3.0\include
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../src/: system_stm32f10x.c
  group Doc
    ./: readme.txt
  group EWARMv6
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group FreeRTOS
    ../../../Utilities/Third_Party/FreeRTOSV7.3.0/: list.c queue.c tasks.c timers.c
  group FreeRTOS/portable
    ../../../Utilities/Third_Party/FreeRTOSV7.3.0/portable/MemMang/: heap_4.c
    ../../../Utilities/Third_Party/FreeRTOSV7.3.0/portable/IAR/ARM_CM3/: port.c portasm.s
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../src/: charging.c eeprom.c flash_if.c main.c slef_buffer.c stm32f10x_it.c
    ../inc/: FreeRTOSConfig.h
    ../Application/: global_value.c
  group User/driver
    ../Application/driver/: drv_adc.c drv_keys.c drv_led_relay.c drv_spi.c drv_timer.c drv_usart.c i2cdev.c i2croutines.c
  group User/eMPL
    ../Application/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group User/Hardware
    ../Application/Hardware/: esp8266.c esp8266.h rn8209.c rn8209.h
  group User/Hardware/MPU6050
    ../Application/Hardware/MPU6050/: mpu6050.c quaternion.c vector3d.c
  group User/protocol
    ../Application/protocol/: protocol.c
  group User/QP-nano
    ../Application/QP-nano/: qepn.c
  group User/userlib
    ../Application/userlib/: user_bus.c user_crc.c
